# Keil uVision project stm32f429_zdyz_board.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f429_zdyz_board +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx,CMSIS_device_header=\"stm32f4xx.h\"
  c include: ..\users;..\drivers\bsp\inc;..\utilities;..\utilities\math;..\drivers\cmsis-device-f4\Include;..\drivers\stm32f4xx-hal-driver\Inc;..\drivers\stm32f4xx-hal-driver\Inc\Legacy;..\drivers\bsp\stm32;..\drivers\CMSIS_6\CMSIS\Core\Include;..\drivers\CMSIS_6\CMSIS\Core\Include\m-profile;..\devices
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x2f800
  memory RVCT10: RAM 0x2002f800 size 0x800
  group users
    ../users/: main.c board.c stm32f4xx_hal_conf.h
  group devices
    ../devices/: gpio.c key.c led_gpio.c serial.c led_core.c
  group drivers/bsp
    ../drivers/bsp/stm32/: stm32_clk.c stm32_gpio.c stm32_it.c stm32_usart.c
  group drivers/STM32_HAL_Driver
    ../drivers/stm32f4xx-hal-driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_adc.c
  group drivers/CMSIS
    ../drivers/cmsis-device-f4/Source/Templates/: system_stm32f4xx.c
    ../drivers/cmsis-device-f4/Source/Templates/arm/: startup_stm32f429xx.s
  group utilities
    ../utilities/: kfifo.c crc.c stimer.c sort_algo.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDERR:Event Recorder 1.1.0, CMSIS-Compiler:STDOUT:Event Recorder 1.1.0, CMSIS-View:Event Recorder 1.6.0, CMSIS:CORE 6.1.1, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:FreeRTOS 11.2.0, RTOS:Config 11.2.0, RTOS:Core 11.2.0, RTOS:Event Groups 11.2.0, RTOS:Heap 11.2.0, RTOS:Timers 11.2.0
